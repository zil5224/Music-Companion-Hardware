# Keil uVision project Zily-Hardware.uvprojx, settings and files
target Zily-Hardware (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: Zily-Hardware +hex
  c flags: Optim=2
  c define: STM32F10X_MD
  c include: ..\FreeRTOS\Config;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\Drivers\USART;..\Drivers\OLED;..\Drivers\KEY;..\Drivers\ENCODER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../App/: main.c zily_uart_service.c zily_uart_service.h zily_uart_protocol.c zily_uart_protocol.h zily_app_state.c zily_app_state.h zily_display_service.c zily_display_service.h zily_oled_demo.c zily_oled_demo.h zily_input_service.c zily_input_service.h
  group Drivers
    ../Drivers/USART/: zily_usart.c zily_usart.h
    ../Drivers/: zily_display_board.h
    ../Drivers/I2C/: zily_i2c.c zily_i2c.h
    ../Drivers/OLED/: zily_oled.c zily_oled.h
    ../Drivers/KEY/: zily_key.c zily_key.h
    ../Drivers/ENCODER/: zily_encoder.c zily_encoder.h
  group FreeRTOS
    ../FreeRTOS/Source/: list.c tasks.c queue.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/Config/: FreeRTOSHooks.c FreeRTOSConfig.h
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
